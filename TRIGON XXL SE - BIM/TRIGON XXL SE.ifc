Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcEnergyConversionDevice: XXL SE 850, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900:XXL SE 850:540139
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1170 mm; B1: 1025 mm; B2: 585 mm; B3: 145 mm; B4: 960 mm; B5: 150 mm; B6: 880 mm; D: 350 mm; G: 60 mm; H1: 960 mm; H2: 660 mm; H3: 530 mm; H4: 500 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 500 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 200 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 326 mm; Подключение воды: 80 mm; Подключение газа: 50 mm; Подключение дымохода: 350 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 102 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1124 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 150 mm; Ширина W: 1025 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 616 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 72.7 дБ(А)
Type - Текст - ADSK_Масса: 958
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 1270 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 21
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 850; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 850; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 850; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 850
Размеры - Смещение водяного соединителя: 0 mm; Объем: 3.49254 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1
