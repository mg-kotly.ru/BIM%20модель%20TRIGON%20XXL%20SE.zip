Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-28T23:56:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1545(x64) - Exporter 17.0.511.0 - Альтернативный интерфейс 17.14.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 28 23:56:12 2020 * Host: 189-i7-2600k * Database: C:\Users\EAD1D~1.PID\AppData\Local\Temp\{6B61DADE-ADE2-4285-A9B7-264E152DDB53}\ifc * Database version: 5507 * Database creation date: Mon Sep 28 23:56:07 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 28 23:56:07 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 28 23:56:07 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcEnergyConversionDevice: XXL SE 1000, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900:XXL SE 1000:540149
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581750; ADSK_Марка: TRIGON XXL SE 1000; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL SE, 961 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL SE 1000; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL SE – низкотемпературные котлы с эффективностью до 103,9 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 40000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 20 kg/K/s3; Номинальный расход при ΔT=20: 0.0113889 m3/s; Объем воды: 0.075 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 267000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 242000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 961000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 961000 W; Номинальная тепловая нагрузка макс: 1038000 W; Номинальная тепловая нагрузка мин: 260000 W; Эффективность на макс при 50/30 ⁰С: 0.926; Эффективность на макс при 80/60 ⁰С: 0.926; Эффективность на мин при 50/30 ⁰С: 1.026; Эффективность на мин при 80/60 ⁰С: 0.932
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0309904 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.00776253 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900; Макс. температура дымовых газов при 80⁄60 oС: 182 kg/K/s3; Максимальный объемный расход конденсата: 4,8 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 7 мг/кВт∙ч; Максимальный уровень NOx: 45 мг/кВт∙ч; Массовый расход дымовых газов макс: 1650 кг/ч; Массовый расход дымовых газов мин: 449 кг/ч; Объемный расход дымовых газов макс: 0.590556 m3/s; Объемный расход дымовых газов мин: 0.117222 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1170 mm; B1: 1075 mm; B2: 585 mm; B3: 95 mm; B4: 960 mm; B5: 100 mm; B6: 980 mm; D: 400 mm; G: 60 mm; H1: 960 mm; H2: 660 mm; H3: 530 mm; H4: 500 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 500 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 250 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 326 mm; Подключение воды: 80 mm; Подключение газа: 50 mm; Подключение дымохода: 400 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 127 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1124 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 100 mm; Ширина W: 1075 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 697.4 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 72.7 дБ(А)
Type - Текст - ADSK_Масса: 1084
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 1270 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 22
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1000; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1000; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1000; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1000
Размеры - Смещение водяного соединителя: 0 mm; Объем: 3.50059 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL SE 1100, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900:XXL SE 1100:540157
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581751; ADSK_Марка: TRIGON XXL SE 1100; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL SE, 1073 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL SE 1100; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL SE – низкотемпературные котлы с эффективностью до 103,9 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 51000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 20 kg/K/s3; Номинальный расход при ΔT=20: 0.0127778 m3/s; Объем воды: 0.08 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 298000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 270000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1074000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1073000 W; Номинальная тепловая нагрузка макс: 1159000 W; Номинальная тепловая нагрузка мин: 290000 W; Эффективность на макс при 50/30 ⁰С: 0.926; Эффективность на макс при 80/60 ⁰С: 0.926; Эффективность на мин при 50/30 ⁰С: 1.026; Эффективность на мин при 80/60 ⁰С: 0.932
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.034603 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.00865821 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900; Макс. температура дымовых газов при 80⁄60 oС: 182 kg/K/s3; Максимальный объемный расход конденсата: 5,3 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 7 мг/кВт∙ч; Максимальный уровень NOx: 45 мг/кВт∙ч; Массовый расход дымовых газов макс: 1842 кг/ч; Массовый расход дымовых газов мин: 501 кг/ч; Объемный расход дымовых газов макс: 0.659444 m3/s; Объемный расход дымовых газов мин: 0.130833 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1225 mm; B2: 685 mm; B3: 145 mm; B4: 1160 mm; B5: 150 mm; B6: 1080 mm; D: 400 mm; G: 76 mm; H1: 960 mm; H2: 660 mm; H3: 530 mm; H4: 500 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 500 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 250 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 326 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 400 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 127 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 150 mm; Ширина W: 1225 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 778.5 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 72.7 дБ(А)
Type - Текст - ADSK_Масса: 1221
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 1270 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 23
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1100; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1100; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1100; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1100
Размеры - Смещение водяного соединителя: 0 mm; Объем: 4.07972 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL SE 1200, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900:XXL SE 1200:540165
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581752; ADSK_Марка: TRIGON XXL SE 1200; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL SE, 1184 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL SE 1200; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL SE – низкотемпературные котлы с эффективностью до 103,9 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 62000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 20 kg/K/s3; Номинальный расход при ΔT=20: 0.0141667 m3/s; Объем воды: 0.085 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 328000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 298000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1185000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1184000 W; Номинальная тепловая нагрузка макс: 1279000 W; Номинальная тепловая нагрузка мин: 320000 W; Эффективность на макс при 50/30 ⁰С: 0.926; Эффективность на макс при 80/60 ⁰С: 0.926; Эффективность на мин при 50/30 ⁰С: 1.026; Эффективность на мин при 80/60 ⁰С: 0.932
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0381857 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.00955389 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900; Макс. температура дымовых газов при 80⁄60 oС: 182 kg/K/s3; Максимальный объемный расход конденсата: 5,9 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 7 мг/кВт∙ч; Максимальный уровень NOx: 45 мг/кВт∙ч; Массовый расход дымовых газов макс: 2033 кг/ч; Массовый расход дымовых газов мин: 552 кг/ч; Объемный расход дымовых газов макс: 0.7275 m3/s; Объемный расход дымовых газов мин: 0.144167 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1275 mm; B2: 685 mm; B3: 95 mm; B4: 1160 mm; B5: 100 mm; B6: 1180 mm; D: 400 mm; G: 76 mm; H1: 960 mm; H2: 660 mm; H3: 530 mm; H4: 500 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 500 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 250 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 326 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 400 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 127 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 100 mm; Ширина W: 1275 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 859.4 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 72.7 дБ(А)
Type - Текст - ADSK_Масса: 1369
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 1270 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 24
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1200; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1200; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1200; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1200
Размеры - Смещение водяного соединителя: 0 mm; Объем: 4.08741 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL SE 1300, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900:XXL SE 1300:540173
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581753; ADSK_Марка: TRIGON XXL SE 1300; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL SE, 1296 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL SE 1300; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL SE – низкотемпературные котлы с эффективностью до 103,9 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 92000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 20 kg/K/s3; Номинальный расход при ΔT=20: 0.0155556 m3/s; Объем воды: 0.097 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 359000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 326000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1297000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1296000 W; Номинальная тепловая нагрузка макс: 1400000 W; Номинальная тепловая нагрузка мин: 350000 W; Эффективность на макс при 50/30 ⁰С: 0.926; Эффективность на макс при 80/60 ⁰С: 0.926; Эффективность на мин при 50/30 ⁰С: 1.026; Эффективность на мин при 80/60 ⁰С: 0.932
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0417983 m3/s; Минимальное давление природного газа G20: 5000 Pa; Минимальное давление природного газа G25: 5000 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.0104496 m3/s; Номинальное давление природного газа G20: 5000 Pa; Номинальное давление природного газа G25: 5000 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900; Макс. температура дымовых газов при 80⁄60 oС: 182 kg/K/s3; Максимальный объемный расход конденсата: 6,4 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 7 мг/кВт∙ч; Максимальный уровень NOx: 45 мг/кВт∙ч; Массовый расход дымовых газов макс: 2225 кг/ч; Массовый расход дымовых газов мин: 604 кг/ч; Объемный расход дымовых газов макс: 0.796389 m3/s; Объемный расход дымовых газов мин: 0.157778 m3/s
Type - Размеры - ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2795 mm; ADSK_Размер_Ширина: 1570 mm; B1: 1445 mm; B2: 785 mm; B3: 145 mm; B4: 1360 mm; B5: 145 mm; B6: 1300 mm; D: 450 mm; G: 76 mm; H1: 895 mm; H2: 420 mm; H3: 470 mm; H4: 240 mm; L1: 480 mm; L2: 1030 mm; L3: 350 mm; L4: 230 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 420 mm; Высота W: 240 mm; Высота дымовых газов: 470 mm; Высота слива: 161 mm; Глубина блока: 2085 mm; Горелка 1: no; Горелка 2: yes; Диаметр компенсатора: 270 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 1 mm; Длина 2_2: 968 mm; Длина 2_3: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 450 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 137 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1524 mm; Смещение соединения воды: 1225 mm; Соединитель 1: no; Соединитель 1 Длина: 480 mm; Соединитель 2: yes; Соединитель 2 Длина: 0 mm; Ширина G: 1445 mm; Ширина W: 145 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 945.4 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 72.7 дБ(А)
Type - Текст - ADSK_Масса: 1380
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2330 W; Потребляемая котлом электрическая мощность мин: 585 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 25
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1300; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1300; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1300; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1300
Размеры - Смещение водяного соединителя: 0 mm; Объем: 4.69934 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL SE 1500, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900:XXL SE 1500:540181
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581754; ADSK_Марка: TRIGON XXL SE 1500; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL SE, 1481 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL SE 1500; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL SE – низкотемпературные котлы с эффективностью до 103,9 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 80000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 20 kg/K/s3; Номинальный расход при ΔT=20: 0.0177778 m3/s; Объем воды: 0.109 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 410000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 373000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1482000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1481000 W; Номинальная тепловая нагрузка макс: 1600000 W; Номинальная тепловая нагрузка мин: 400000 W; Эффективность на макс при 50/30 ⁰С: 0.926; Эффективность на макс при 80/60 ⁰С: 0.926; Эффективность на мин при 50/30 ⁰С: 1.026; Эффективность на мин при 80/60 ⁰С: 0.932
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0477694 m3/s; Минимальное давление природного газа G20: 5000 Pa; Минимальное давление природного газа G25: 5000 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.0119424 m3/s; Номинальное давление природного газа G20: 5000 Pa; Номинальное давление природного газа G25: 5000 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900; Макс. температура дымовых газов при 80⁄60 oС: 182 kg/K/s3; Максимальный объемный расход конденсата: 7 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 7 мг/кВт∙ч; Максимальный уровень NOx: 45 мг/кВт∙ч; Массовый расход дымовых газов макс: 2543 кг/ч; Массовый расход дымовых газов мин: 691 кг/ч; Объемный расход дымовых газов макс: 0.910278 m3/s; Объемный расход дымовых газов мин: 0.180278 m3/s
Type - Размеры - Горелка 1: no; Горелка 2: yes; Соединитель 1: no; Соединитель 2: yes; Соединитель 2 Длина: 0 mm; ADSK_Размер_Высота: 1575 mm; ADSK_Размер_Глубина: 3310 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1250 mm; B2: 685 mm; B3: 145 mm; B4: 1160 mm; B5: 145 mm; B6: 1105 mm; D: 450 mm; G: 76 mm; H1: 915 mm; H2: 435 mm; H3: 490 mm; H4: 260 mm; L1: 480 mm; L2: 1550 mm; L3: 350 mm; L4: 230 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 435 mm; Высота W: 260 mm; Высота дымовых газов: 490 mm; Высота слива: 161 mm; Глубина блока: 2600 mm; Диаметр компенсатора: 270 mm; Длина 1_1: 512 mm; Длина 1_2: 679.5 mm; Длина 1_3: 679.5 mm; Длина 2_1: 512 mm; Длина 2_2: 968 mm; Длина 2_3: 1 mm; Длина 3_1: 2448 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 450 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 137 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 1 Длина: 480 mm; Ширина G: 1250 mm; Ширина W: 145 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 770 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 72.7 дБ(А)
Type - Текст - ADSK_Масса: 1740
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2330 W; Потребляемая котлом электрическая мощность мин: 585 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 26
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1500; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1500; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1500; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1500
Размеры - Смещение водяного соединителя: 0 mm; Объем: 5.16991 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL SE 1700, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900:XXL SE 1700:540466
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581755; ADSK_Марка: TRIGON XXL SE 1700; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL SE, 1666 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL SE 1700; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL SE – низкотемпературные котлы с эффективностью до 103,9 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 108000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 20 kg/K/s3; Номинальный расход при ΔT=20: 0.02 m3/s; Объем воды: 0.116 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 462000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 419000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1667000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1666000 W; Номинальная тепловая нагрузка макс: 1800000 W; Номинальная тепловая нагрузка мин: 450000 W; Эффективность на макс при 50/30 ⁰С: 0.926; Эффективность на макс при 80/60 ⁰С: 0.926; Эффективность на мин при 50/30 ⁰С: 1.026; Эффективность на мин при 80/60 ⁰С: 0.932
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0537406 m3/s; Минимальное давление природного газа G20: 5000 Pa; Минимальное давление природного газа G25: 5000 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.0134352 m3/s; Номинальное давление природного газа G20: 5000 Pa; Номинальное давление природного газа G25: 5000 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900; Макс. температура дымовых газов при 80⁄60 oС: 182 kg/K/s3; Максимальный объемный расход конденсата: 8 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 7 мг/кВт∙ч; Максимальный уровень NOx: 45 мг/кВт∙ч; Массовый расход дымовых газов макс: 2861 кг/ч; Массовый расход дымовых газов мин: 777 кг/ч; Объемный расход дымовых газов макс: 1.02389 m3/s; Объемный расход дымовых газов мин: 0.202778 m3/s
Type - Размеры - Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; Горелка 1: no; Горелка 2: yes; Смещение ножек: 1524 mm; ADSK_Размер_Высота: 1575 mm; ADSK_Размер_Глубина: 3310 mm; ADSK_Размер_Ширина: 1570 mm; B1: 1375 mm; B2: 785 mm; B3: 195 mm; B4: 1360 mm; B5: 190 mm; B6: 1180 mm; D: 500 mm; G: 89 mm; H1: 915 mm; H2: 260 mm; H3: 490 mm; H4: 440 mm; L1: 480 mm; L2: 1550 mm; L3: 350 mm; L4: 150 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 440 mm; Высота W: 260 mm; Высота дымовых газов: 490 mm; Высота слива: 161 mm; Глубина блока: 2600 mm; Диаметр компенсатора: 300 mm; Длина 1_1: 512 mm; Длина 1_2: 679.5 mm; Длина 1_3: 679.5 mm; Длина 2_1: 512 mm; Длина 2_2: 968 mm; Длина 2_3: 1 mm; Длина 3_1: 2448 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 80 mm; Подключение дымохода: 500 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 152 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 190 mm; Ширина W: 1375 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 865.4 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 72.7 дБ(А)
Type - Текст - ADSK_Масса: 1899
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2770 W; Потребляемая котлом электрическая мощность мин: 695 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 27
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1700; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1700; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1700; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1700
Размеры - Смещение водяного соединителя: 0 mm; Объем: 5.90668 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL SE 1900, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900:XXL SE 1900:540476
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581756; ADSK_Марка: TRIGON XXL SE 1900; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL SE, 1854 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL SE 1900; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL SE – низкотемпературные котлы с эффективностью до 103,9 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 197000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 20 kg/K/s3; Номинальный расход при ΔT=20: 0.0222222 m3/s; Объем воды: 0.123 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 513000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 466000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1853000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1851000 W; Номинальная тепловая нагрузка макс: 2000000 W; Номинальная тепловая нагрузка мин: 500000 W; Эффективность на макс при 50/30 ⁰С: 0.926; Эффективность на макс при 80/60 ⁰С: 0.926; Эффективность на мин при 50/30 ⁰С: 1.026; Эффективность на мин при 80/60 ⁰С: 0.932
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0597118 m3/s; Минимальное давление природного газа G20: 5000 Pa; Минимальное давление природного газа G25: 5000 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.014928 m3/s; Номинальное давление природного газа G20: 5000 Pa; Номинальное давление природного газа G25: 5000 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900; Макс. температура дымовых газов при 80⁄60 oС: 182 kg/K/s3; Максимальный объемный расход конденсата: 9 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 7 мг/кВт∙ч; Максимальный уровень NOx: 45 мг/кВт∙ч; Массовый расход дымовых газов макс: 3178 кг/ч; Массовый расход дымовых газов мин: 863 кг/ч; Объемный расход дымовых газов макс: 1.13778 m3/s; Объемный расход дымовых газов мин: 0.225278 m3/s
Type - Размеры - Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; Горелка 1: no; Горелка 2: yes; Смещение ножек: 1524 mm; ADSK_Размер_Высота: 1575 mm; ADSK_Размер_Глубина: 3310 mm; ADSK_Размер_Ширина: 1570 mm; B1: 1425 mm; B2: 785 mm; B3: 145 mm; B4: 1360 mm; B5: 140 mm; B6: 1280 mm; D: 500 mm; G: 89 mm; H1: 915 mm; H2: 260 mm; H3: 490 mm; H4: 440 mm; L1: 480 mm; L2: 1550 mm; L3: 350 mm; L4: 150 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 440 mm; Высота W: 260 mm; Высота дымовых газов: 490 mm; Высота слива: 161 mm; Глубина блока: 2600 mm; Диаметр компенсатора: 300 mm; Длина 1_1: 512 mm; Длина 1_2: 679.5 mm; Длина 1_3: 679.5 mm; Длина 2_1: 512 mm; Длина 2_2: 968 mm; Длина 2_3: 1 mm; Длина 3_1: 2448 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 80 mm; Подключение дымохода: 500 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 152 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Ширина G: 140 mm; Ширина W: 1425 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 945.4 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 72.7 дБ(А)
Type - Текст - ADSK_Масса: 1991
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2770 W; Потребляемая котлом электрическая мощность мин: 695 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 28
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1900; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1900; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1900; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 1900
Размеры - Смещение водяного соединителя: 0 mm; Объем: 5.91671 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL SE 650, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900:XXL SE 650:539569
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 475 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581747; ADSK_Марка: TRIGON XXL SE 650; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL SE, 650 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL SE 650; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL SE – низкотемпературные котлы с эффективностью до 103,9 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 38000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 20 kg/K/s3; Номинальный расход при ΔT=20: 0.00777778 m3/s; Объем воды: 0.05 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 181000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 164000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 650000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 650000 W; Номинальная тепловая нагрузка макс: 702000 W; Номинальная тепловая нагрузка мин: 176000 W; Эффективность на макс при 50/30 ⁰С: 0.926; Эффективность на макс при 80/60 ⁰С: 0.926; Эффективность на мин при 50/30 ⁰С: 1.026; Эффективность на мин при 80/60 ⁰С: 0.932
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0209588 m3/s; Минимальное давление природного газа G20: 2500 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00525464 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900; Макс. температура дымовых газов при 80⁄60 oС: 182 kg/K/s3; Максимальный объемный расход конденсата: 3.2 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 7 мг/кВт∙ч; Максимальный уровень NOx: 45 мг/кВт∙ч; Массовый расход дымовых газов макс: 1116 кг/ч; Массовый расход дымовых газов мин: 304 кг/ч; Объемный расход дымовых газов макс: 0.399444 m3/s; Объемный расход дымовых газов мин: 0.0794444 m3/s
Type - Размеры - ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2185 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1185 mm; B2: 685 mm; B3: 185 mm; B4: 1160 mm; B5: 150 mm; B6: 1000 mm; D: 300 mm; G: 60 mm; H1: 960 mm; H2: 660 mm; H3: 540 mm; H4: 480 mm; L1: 475 mm; L2: 660 mm; L3: 210 mm; L4: 110 mm; L5: 420 mm; LW: 185 mm; W: 76 mm; Высота G: 480 mm; Высота W: 660 mm; Высота дымовых газов: 540 mm; Высота слива: 272 mm; Глубина блока: 1710 mm; Горелка 1: yes; Горелка 2: no; Диаметр компенсатора: 180 mm; Длина 1_1: 678.5 mm; Длина 1_2: 1 mm; Длина 1_3: 1 mm; Длина 2_1: 1558 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1558 mm; Длина 3_2: 1 mm; Длина отрезка: 326 mm; Подключение воды: 65 mm; Подключение газа: 50 mm; Подключение дымохода: 300 mm; Подключение забора воздуха_для внешнего забора: 250 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 92 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; Соединитель 2 Длина: 475 mm; Ширина G: 150 mm; Ширина W: 1185 mm; Ширина дымовых газов: 210 mm; Ширина полки Горелки: 808 mm; Ширина слива: 515 mm
Type - Силы - Уровень звуковой мощности: 72.7 дБ(А)
Type - Текст - ADSK_Масса: 770
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 900 W; Потребляемая котлом электрическая мощность мин: 225 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 19
Механизмы - ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; ELCO_Слив: 0; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 650; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 650; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 650; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 650
Размеры - Объем: 3.33301 m3; Смещение водяного соединителя: 0 mm; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL SE 750, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900:XXL SE 750:539988
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581748; ADSK_Марка: TRIGON XXL SE 750; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL SE, 726 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL SE 750; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL SE – низкотемпературные котлы с эффективностью до 103,9 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 43000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 20 kg/K/s3; Номинальный расход при ΔT=20: 0.00861111 m3/s; Объем воды: 0.053 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 201000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 183000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 726000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 726000 W; Номинальная тепловая нагрузка макс: 784000 W; Номинальная тепловая нагрузка мин: 196000 W; Эффективность на макс при 50/30 ⁰С: 0.926; Эффективность на макс при 80/60 ⁰С: 0.926; Эффективность на мин при 50/30 ⁰С: 1.026; Эффективность на мин при 80/60 ⁰С: 0.932
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.023407 m3/s; Минимальное давление природного газа G20: 2500 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00585176 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900; Макс. температура дымовых газов при 80⁄60 oС: 182 kg/K/s3; Максимальный объемный расход конденсата: 3,6 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 7 мг/кВт∙ч; Максимальный уровень NOx: 45 мг/кВт∙ч; Массовый расход дымовых газов макс: 1246 кг/ч; Массовый расход дымовых газов мин: 338 кг/ч; Объемный расход дымовых газов макс: 0.446111 m3/s; Объемный расход дымовых газов мин: 0.0883333 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2185 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1235 mm; B2: 685 mm; B3: 135 mm; B4: 1160 mm; B5: 100 mm; B6: 1100 mm; D: 350 mm; G: 60 mm; H1: 960 mm; H2: 660 mm; H3: 530 mm; H4: 480 mm; L1: 475 mm; L2: 660 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 76 mm; Высота G: 480 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 1710 mm; Диаметр компенсатора: 200 mm; Длина 1_1: 678.5 mm; Длина 1_2: 1 mm; Длина 1_3: 1 mm; Длина 2_1: 1558 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1558 mm; Длина 3_2: 1 mm; Длина отрезка: 419 mm; Подключение воды: 65 mm; Подключение газа: 50 mm; Подключение дымохода: 350 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 102 mm; Служебная подрезка: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 475 mm; Ширина G: 100 mm; Ширина W: 1235 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 860 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 72.7 дБ(А)
Type - Текст - ADSK_Масса: 844
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 900 W; Потребляемая котлом электрическая мощность мин: 225 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Марка: 20
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод дымовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 750; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 750; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 750; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900: XXL SE 750
Размеры - Смещение водяного соединителя: 0 mm; Объем: 3.36054 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL SE 850, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900:XXL SE 850:540139
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 255-255-240, Color RGB 181-181-181, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581749; ADSK_Марка: TRIGON XXL SE 850; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL SE, 849 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL SE 850; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL SE – низкотемпературные котлы с эффективностью до 103,9 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 34000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 20 kg/K/s3; Номинальный расход при ΔT=20: 0.01 m3/s; Объем воды: 0.07 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 235000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 213000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 849000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 849000 W; Номинальная тепловая нагрузка макс: 917000 W; Номинальная тепловая нагрузка мин: 229000 W; Эффективность на макс при 50/30 ⁰С: 0.926; Эффективность на макс при 80/60 ⁰С: 0.926; Эффективность на мин при 50/30 ⁰С: 1.026; Эффективность на мин при 80/60 ⁰С: 0.932
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0273779 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.006837 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_SE_650-1900; Макс. температура дымовых газов при 80⁄60 oС: 182 kg/K/s3; Максимальный объемный расход конденсата: 4,2 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 7 мг/кВт∙ч; Максимальный уровень NOx: 45 мг/кВт∙ч; Массовый расход дымовых газов макс: 1457 кг/ч; Массовый расход дымовых газов мин: 395 кг/ч; Объемный расход дымовых газов макс: 0.521667 m3/s; Объемный расход дымовых газов мин: 0.103333 m3/s
